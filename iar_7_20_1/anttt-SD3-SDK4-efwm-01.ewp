# IAR project anttt-SD3-SDK4-efwm-01.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nrf51422_xxaa NordicSemi nRF51422_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: NRF51
  ICCARM.CCIncludePath2: ..\bsp; ..\application; ..\nordic_sdk6_1_0; ..\nordic_sdk6_1_0\Include; ..\nordic_sdk6_1_0\Include\s310; ..\nordic_sdk6_1_0\Include\ble; ..\nordic_sdk6_1_0\Include\ble\ble_services; ..\nordic_sdk6_1_0\Include\ble\device_manager; ..\nordic_sdk6_1_0\Include\app_common; ..\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\bsp; ..\mpg_application; ..\nordic_sdk4_2_2; ..\nordic_sdk4_2_2\Include; ..\nordic_sdk4_2_2\Include\ant; ..\nordic_sdk4_2_2\Include\app_common; ..\nordic_sdk4_2_2\Source; ..\nordic_sdk4_2_2\Source\app_common
  OBJCOPY.OOCOutputFile: anttt-SD3-SDK4-efwm-01.hex
  ILINK.IlinkOutputFile: mpg51-SD3-SDK4-efwm-01.out
  ILINK.IlinkIcfFile: ..\nordic_sdk4_2_2\Source\nRF51422_QFAA.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group _BSP/Include
    ../bsp/: ant_integration.h anttt-ehdw-04.h ble_integration.h bleperipheral.h configuration.h interrupts.h leds_anttt.h soc_integration.h utilities.h
    ../drivers/: buttons.h
  group _BSP/Source
    ../bsp/: ant_integration.c anttt-ehdw-04.c ble_integration.c bleperipheral.c interrupts.c leds_anttt.c soc_integration.c utilities.c
    ../nordic_sdk6_1_0/: ble_advdata.c ble_advdata_parser.c
    ../drivers/: buttons.c
  group Application/Include
    ../application/: bleperipheral_engenuics.h main.h typedefs.h
    ../nordic_sdk4_2_2/Source/: nRF51422_QFAA.icf
  group Application/Source
    ../application/: anttt.c anttt.h bleperipheral_engenuics.c main.c
    ../nordic_sdk6_1_0/: iar_startup_nrf51.s system_nrf51422.c
